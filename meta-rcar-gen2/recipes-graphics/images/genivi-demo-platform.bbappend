# Add R-Car gfx and multimedia packages to the image when enabled
include core-image-weston.inc
